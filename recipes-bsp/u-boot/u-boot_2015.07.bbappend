FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

PV = "2015.07"

SRC_URI_append_overo += "file://0001-Add-exra-address-for-expansion-board-detection.patch"

